options:
  parameters:
    author: Juanjo
    description: 'Receptor de sondador ionosferico: Golay 16 bits + QCC (Red Pitaya SDRlab 122-16)'
    generate_options: qt_gui
    id: ionosonde_rx
    output_language: python
    title: Sondador ionosferico - Receptor Golay/QCC
  states: {}

blocks:
- name: K
  id: variable
  parameters:
    comment: Parejas A/B integradas
    value: '25'
  states: {}
- name: c
  id: variable
  parameters:
    value: '299792458.0'
  states: {}
- name: code_A
  id: variable
  parameters:
    value: '[1, 1, 1, -1, 1, 1, -1, 1, 1, 1, 1, -1, -1, -1, 1, -1]'
  states: {}
- name: code_B
  id: variable
  parameters:
    value: '[1, 1, 1, -1, 1, 1, -1, 1, -1, -1, -1, 1, 1, 1, -1, 1]'
  states: {}
- name: dh_km
  id: variable
  parameters:
    comment: Altura por muestra = 0.75 km (h' = c t / 2)
    value: c / (2.0 * samp_rate) / 1000.0
  states: {}
- name: n_vec
  id: variable
  parameters:
    comment: |-
      Muestras por PRT = 3333.
      200000/60 = 3333.33 -> deriva 1/3 muestra por disparo.
    value: int(samp_rate // prf)
  states: {}
- name: prf
  id: variable
  parameters:
    comment: Frecuencia de repeticion de pulso [Hz]
    value: '60'
  states: {}
- name: rp_device
  id: variable
  parameters:
    comment: |-
      Nombre del dispositivo IIO del ADC.
      Verificar con: iio_info -u ip:192.168.1.100
    value: '''rp-adc'''
  states: {}
- name: rp_uri
  id: variable
  parameters:
    comment: URI libiio de la Red Pitaya (iiod)
    value: '''ip:192.168.1.100'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Frecuencia de muestreo en banda base (DDC en la FPGA)
    value: '200000'
  states: {}
- name: spb
  id: variable
  parameters:
    comment: Muestras por chip (30 us x 200 kS/s)
    value: '6'
  states: {}
- name: swap_ab
  id: variable_qtgui_check_box
  parameters:
    comment: |-
      Marcar si la rama A esta recibiendo los disparos B
      (el demux arranca en la fase equivocada).
    'false': '0'
    gui_hint: 0,0,1,1
    label: '''Intercambiar A/B'''
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: taps_A
  id: variable
  parameters:
    comment: 'Filtro adaptado A: codigo invertido y sobremuestreado x6'
    value: np.repeat(code_B if swap_ab else code_A, spb)[::-1].astype(complex).tolist()
  states: {}
- name: taps_B
  id: variable
  parameters:
    comment: Filtro adaptado B
    value: np.repeat(code_A if swap_ab else code_B, spb)[::-1].astype(complex).tolist()
  states: {}
- name: zmq_addr
  id: variable
  parameters:
    value: '''tcp://127.0.0.1:5555'''
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: 'Suma complementaria QCC: A + B'
    type: complex
    vlen: n_vec
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: Envolvente |Z|
    vlen: n_vec
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    blocksize: n_vec
    comment: |-
      Segmentacion por PRT + selector Golay:
      bloque par -> A, bloque impar -> B
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    comment: Suma de K perfiles
    decim: K
    type: float
    vlen: n_vec
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Promedio (/K)
    const: '[1.0 / K] * n_vec'
    type: float
    vlen: n_vec
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32768'
  states: {}
- name: blocks_short_to_float_1
  id: blocks_short_to_float
  parameters:
    scale: '32768'
  states: {}
- name: blocks_stream_to_vector_A
  id: blocks_stream_to_vector
  parameters:
    num_items: n_vec
    type: complex
  states: {}
- name: blocks_stream_to_vector_B
  id: blocks_stream_to_vector
  parameters:
    num_items: n_vec
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: n_vec
    type: float
  states: {}
- name: filter_fir_filter_A
  id: fir_filter_xxx
  parameters:
    comment: Correlador A
    decim: '1'
    taps: taps_A
    type: ccc
  states: {}
- name: filter_fir_filter_B
  id: fir_filter_xxx
  parameters:
    comment: Correlador B
    decim: '1'
    taps: taps_B
    type: ccc
  states: {}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: n_vec * 4
    channels: '[''voltage0'', ''voltage1'']'
    comment: |-
      Red Pitaya SDRlab 122-16 via iiod.
      Canal voltage0 = I, voltage1 = Q.
    decimation: '1'
    device: rp_device
    device_phy: ''''''
    params: '[]'
    uri: rp_uri
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_raster_sink_f_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 2,0,1,2
    name: '''Matriz 2D (perfil vs. tiempo)'''
    ncols: n_vec
    nrows: '100'
    samp_rate: samp_rate
    type: float
    x_end_value: (n_vec - 16 * spb + 1) * dh_km
    x_label: '''Altura virtual h [km]'''
    x_start_value: '-(16 * spb - 1) * dh_km'
    y_end_value: '100'
    y_label: '''Perfil'''
    y_start_value: '0'
    zmin: '0'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,0,1,2
    name: '''Perfil de altura virtual'''
    vlen: n_vec
    x_axis_label: '''Altura virtual h [km]'''
    x_start: '-(16 * spb - 1) * dh_km'
    x_step: dh_km
    x_units: '''km'''
    y_axis_label: '''Amplitud'''
    y_units: ''''''
    ymax: '1'
    ymin: '0'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: zmq_addr
    comment: Perfil promediado hacia ionogram_gui.py
    key: ''''''
    timeout: '100'
    type: float
    vlen: n_vec
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '''tcp://127.0.0.1:5556'''
    comment: |-
      Fuente de simulacion (sin hardware).
      Habilitarla y deshabilitar la rama IIO.
    key: ''''''
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_add_xx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_integrate_xx_0, '0']
- [blocks_deinterleave_0, '0', filter_fir_filter_A, '0']
- [blocks_deinterleave_0, '1', filter_fir_filter_B, '0']
- [blocks_float_to_complex_0, '0', blocks_deinterleave_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_multiply_const_vxx_0, '0', zeromq_pub_sink_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_1, '0', blocks_float_to_complex_0, '1']
- [blocks_stream_to_vector_A, '0', blocks_add_xx_0, '0']
- [blocks_stream_to_vector_B, '0', blocks_add_xx_0, '1']
- [blocks_vector_to_stream_0, '0', qtgui_time_raster_sink_f_0, '0']
- [filter_fir_filter_A, '0', blocks_stream_to_vector_A, '0']
- [filter_fir_filter_B, '0', blocks_stream_to_vector_B, '0']
- [iio_device_source_0, '0', blocks_short_to_float_0, '0']
- [iio_device_source_0, '1', blocks_short_to_float_1, '0']
- [zeromq_sub_source_0, '0', blocks_deinterleave_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
