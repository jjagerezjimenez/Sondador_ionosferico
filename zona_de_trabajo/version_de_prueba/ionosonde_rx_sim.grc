options:
  parameters:
    author: Juanjo
    description: 'Simulacion del receptor del sondador ionosferico: Golay 16 bits + QCC + integracion coherente + ionograma. GUI en ionosonde_gui.py'
    generate_options: qt_gui
    id: ionosonde_rx_sim
    output_language: python
    title: Sondador ionosferico - Simulacion del receptor Golay/QCC
  states: {}

blocks:
- name: K
  id: variable
  parameters:
    comment: |-
      Parejas A/B integradas.
      Fijo en ejecucion.
    value: '25'
  states: {}
- name: c_luz
  id: variable
  parameters:
    comment: Velocidad de la luz [m/s]
    value: '299792458.0'
  states: {}
- name: code_A
  id: variable
  parameters:
    comment: Codigo Golay A
    value: '[1, 1, 1, -1, 1, 1, -1, 1, 1, 1, 1, -1, -1, -1, 1, -1]'
  states: {}
- name: code_B
  id: variable
  parameters:
    comment: Codigo Golay B
    value: '[1, 1, 1, -1, 1, 1, -1, 1, -1, -1, -1, 1, 1, 1, -1, 1]'
  states: {}
- name: dh_km
  id: variable
  parameters:
    comment: |-
      km por muestra = 0.7495
      (h' = c t / 2)
    value: c_luz / (2.0 * samp_rate) / 1000.0
  states: {}
- name: doppler_hz
  id: variable
  parameters:
    comment: Doppler del eco [Hz]
    value: '0.2'
  states: {}
- name: f_fija
  id: variable
  parameters:
    comment: frecuencia fija [MHz]
    value: '5.0'
  states: {}
- name: f_fin
  id: variable
  parameters:
    comment: fin barrido [MHz]
    value: '20.0'
  states: {}
- name: f_ini
  id: variable
  parameters:
    comment: inicio barrido [MHz]
    value: '1.0'
  states: {}
- name: foE
  id: variable
  parameters:
    comment: |-
      Panel de control (GUI):
      critica capa E [MHz]
    value: '3.0'
  states: {}
- name: foF2
  id: variable
  parameters:
    comment: critica capa F2 [MHz]
    value: '8.0'
  states: {}
- name: h_off
  id: variable
  parameters:
    comment: |-
      Retardo del correlador:
      eco a h -> muestra h/dh + h_off
    value: n_chips * spb - 1
  states: {}
- name: hmF2
  id: variable
  parameters:
    comment: altura max. F2 [km]
    value: '300.0'
  states: {}
- name: integracion
  id: variable
  parameters:
    comment: |-
      0 = coherente
      1 = incoherente
    value: '0'
  states: {}
- name: modo_barrido
  id: variable
  parameters:
    comment: 1 = barrido, 0 = fija
    value: '1'
  states: {}
- name: n_chips
  id: variable
  parameters:
    comment: Chips por codigo Golay
    value: '16'
  states: {}
- name: n_h
  id: variable
  parameters:
    comment: |-
      Alturas por perfil: 0..2398 km.
      3200 = 2^7*25 -> buffers chicos
      (con 3333 cada buffer vectorial
      ocupa 218 MB en Windows)
    value: '3200'
  states: {}
- name: n_vec
  id: variable
  parameters:
    comment: |-
      Muestras por disparo (PRT)
      = 3333
    value: int(samp_rate // prf)
  states: {}
- name: paso_mhz
  id: variable
  parameters:
    comment: paso barrido [MHz]
    value: '0.1'
  states: {}
- name: prf
  id: variable
  parameters:
    comment: |-
      Frecuencia de repeticion
      de pulso [Hz]
    value: '60'
  states: {}
- name: pulso_directo
  id: variable
  parameters:
    comment: acople TX->RX (0/1)
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Muestreo en banda base [S/s]
      (DDC en la FPGA)
    value: '200000'
  states: {}
- name: segundo_salto
  id: variable
  parameters:
    comment: eco 2F (0/1)
    value: '1'
  states: {}
- name: snr_db
  id: variable
  parameters:
    comment: |-
      SNR de entrada
      por muestra [dB]
    value: '-15.0'
  states: {}
- name: spb
  id: variable
  parameters:
    comment: |-
      Muestras por chip
      (30 us x 200 kS/s)
    value: '6'
  states: {}
- name: swap_ab
  id: variable
  parameters:
    comment: |-
      1 = correladores A/B
      intercambiados (GUI)
    value: '0'
  states: {}
- name: taps_A
  id: variable
  parameters:
    comment: |-
      Filtro adaptado A: codigo
      invertido y sobremuestreado x6
    value: np.repeat(code_B if swap_ab else code_A, spb)[::-1].astype(complex).tolist()
  states: {}
- name: taps_B
  id: variable
  parameters:
    comment: Filtro adaptado B
    value: np.repeat(code_A if swap_ab else code_B, spb)[::-1].astype(complex).tolist()
  states: {}
- name: velocidad
  id: variable
  parameters:
    comment: x tiempo real
    value: '10'
  states: {}
- name: zmq_addr
  id: variable
  parameters:
    comment: Perfiles hacia ionogram_gui.py
    value: '''tcp://127.0.0.1:5555'''
  states: {}
- name: blocks_throttle
  id: blocks_throttle2
  parameters:
    comment: |-
      Ritmo de la simulacion:
      samp_rate x velocidad
    samples_per_second: samp_rate * velocidad
    type: complex
  states: {}
- name: correlador_A
  id: fir_filter_xxx
  parameters:
    comment: |-
      Correlador A
      (filtro adaptado)
    decim: '1'
    taps: taps_A
    type: ccc
  states: {}
- name: correlador_B
  id: fir_filter_xxx
  parameters:
    comment: |-
      Correlador B
      (filtro adaptado)
    decim: '1'
    taps: taps_B
    type: ccc
  states: {}
- name: envolvente_c
  id: blocks_complex_to_mag
  parameters:
    comment: '|Z|'
    vlen: n_h
  states: {}
- name: envolvente_i
  id: blocks_complex_to_mag
  parameters:
    comment: '|Z| de cada disparo'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: integrador_coherente
  id: blocks_integrate_xx
  parameters:
    comment: |-
      INTEGRACION COHERENTE:
      suma K perfiles I/Q
    decim: K
    type: complex
    vlen: n_h
  states: {}
- name: integrador_incoherente
  id: blocks_integrate_xx
  parameters:
    comment: |-
      INTEGRACION INCOHERENTE:
      suma K perfiles |Z|
    decim: K
    type: float
    vlen: n_h
  states: {}
- name: interfaz_grafica
  id: snippet
  parameters:
    code: |-
      # Interfaz grafica: panel de control + pestanas de graficos.
      # El codigo esta en ionosonde_gui.py (misma carpeta que este .grc).
      import os, sys
      sys.path.insert(0, os.path.dirname(os.path.abspath(__file__)))
      import ionosonde_gui
      self._gui = ionosonde_gui.instalar(self)
    comment: |-
      Arma la GUI (controles + pestanas)
      definida en ionosonde_gui.py
    section: main_after_init
  states: {}
- name: ionograma
  id: epy_block
  parameters:
    _source_code: |
      """
      Armado del ionograma.

      Recibe cada perfil de altura ya integrado (vector de n_h alturas,
      h = i * dh_km) y, con el tag 'sondeo' que viaja junto al perfil, sabe a que
      frecuencia corresponde. Guarda:
        * matriz_db[f, h]: ionograma en dB sobre el piso de ruido de cada perfil
          (piso = mediana del perfil).
        * traza_h[f]: altura del eco mas fuerte (si supera 'umbral_db').
        * ultimo: el ultimo perfil recibido (lineal y en dB) con su frecuencia.
        * historial: los ultimos perfiles en dB (para el grafico altura-tiempo).
      La interfaz grafica lee estos atributos.
      """
      import collections
      import threading
      import numpy as np
      import pmt
      from gnuradio import gr

      TAG_SONDEO = pmt.intern('sondeo')


      class blk(gr.sync_block):
          """Armado del ionograma h'(f): ubica cada perfil integrado en la columna de su
          frecuencia (leida del tag 'sondeo') y detecta el eco mas fuerte."""

          def __init__(self, n_h=3200, dh_km=0.7494811, f_min=1.0, f_max=20.0, df_grilla=0.05,
                       umbral_db=12.0, h_min_km=80.0):
              gr.sync_block.__init__(self, name='Armado del ionograma',
                                     in_sig=[(np.float32, int(n_h))], out_sig=None)
              self.n_h = int(n_h)
              self.dh_km = float(dh_km)
              self.f_min, self.f_max, self.df = float(f_min), float(f_max), float(df_grilla)
              self.n_f = int(round((self.f_max - self.f_min) / self.df)) + 1
              self.umbral_db = umbral_db
              self._i_hmin = int(np.ceil(float(h_min_km) / self.dh_km))
              self.lock = threading.Lock()
              self._info = {}
              self.contador = 0
              self.ultimo = None                                 # (contador, info, perfil_lin, perfil_db)
              self.historial = collections.deque(maxlen=200)     # (info, perfil_db)
              self.limpiar()

          def limpiar(self):
              with self.lock:
                  self.matriz_db = np.full((self.n_f, self.n_h), np.nan, np.float32)
                  self.traza_h = np.full(self.n_f, np.nan)
                  self.traza_db = np.full(self.n_f, np.nan)

          def columnas(self, f_mhz, paso_mhz):
              """Columnas de la grilla de frecuencia que cubre un paso del barrido."""
              ancho = max(float(paso_mhz), self.df)
              i0 = int(np.floor((f_mhz - ancho / 2.0 - self.f_min) / self.df + 0.5))
              i1 = int(np.floor((f_mhz + ancho / 2.0 - self.f_min) / self.df + 0.5))
              i0, i1 = max(i0, 0), min(max(i1, i0 + 1), self.n_f)
              return i0, i1

          def work(self, input_items, output_items):
              perfiles = input_items[0]
              n = len(perfiles)
              base = self.nitems_read(0)
              info_en = {t.offset - base: pmt.to_python(t.value)
                         for t in self.get_tags_in_window(0, 0, n, TAG_SONDEO)}
              for j in range(n):
                  if j in info_en:
                      self._info = info_en[j]
                  perfil = np.array(perfiles[j], dtype=np.float32)
                  piso = float(np.median(perfil)) or 1e-12
                  perfil_db = 20.0 * np.log10(np.maximum(perfil, 1e-12) / piso)
                  f = self._info.get('f_mhz')
                  with self.lock:
                      if f is not None and self.f_min - self.df <= f <= self.f_max + self.df:
                          i0, i1 = self.columnas(f, self._info.get('paso_mhz', 0.0))
                          self.matriz_db[i0:i1] = perfil_db
                          k = self._i_hmin + int(np.argmax(perfil_db[self._i_hmin:]))
                          detectado = perfil_db[k] >= float(self.umbral_db)
                          self.traza_h[i0:i1] = k * self.dh_km if detectado else np.nan
                          self.traza_db[i0:i1] = perfil_db[k] if detectado else np.nan
                      self.contador += 1
                      self.ultimo = (self.contador, dict(self._info), perfil, perfil_db)
                      self.historial.append((dict(self._info), perfil_db))
              return n
    comment: |-
      Armado del ionograma h'(f):
      ubica cada perfil en la columna
      de su frecuencia (tag 'sondeo')
    df_grilla: '0.05'
    dh_km: dh_km
    f_max: f_fin
    f_min: f_ini
    h_min_km: '80.0'
    n_h: n_h
    umbral_db: '14.0'
  states: {}
- name: monitor_correl
  id: epy_block
  parameters:
    _source_code: |
      """
      Monitor de la compresion de pulso (solo visualizacion).

      Entradas (una muestra por muestra de disparo, n_vec por pareja):
        0: salida del correlador A, 1: salida del correlador B, 2: suma A + B.
      Cada 'cada_n_parejas' parejas copia los n_vec valores de cada entrada.
      Usa la misma regla que el monitor de la senal recibida, asi la GUI puede
      comparar la misma pareja en los dos monitores.
      """
      import collections
      import threading
      import numpy as np
      import pmt
      from gnuradio import gr

      TAG_SONDEO = pmt.intern('sondeo')


      class blk(gr.sync_block):
          """Monitor (para la GUI): guarda cada tanto la salida de los correladores A y B
          y de la suma A + B para una misma pareja de disparos."""

          def __init__(self, n_vec=3333, cada_n_parejas=6):
              gr.sync_block.__init__(self, name='Monitor compresion de pulso',
                                     in_sig=[np.complex64, np.complex64, np.complex64], out_sig=None)
              self._n = int(n_vec)
              self._cada = max(1, int(cada_n_parejas))
              self._info = {}
              self._cap = None
              self.lock = threading.Lock()
              self.capturas = collections.deque(maxlen=8)   # (n_pareja, info, A, B, A+B)

          def work(self, input_items, output_items):
              n = len(input_items[0])
              base = self.nitems_read(2)
              tags = sorted(self.get_tags_in_window(2, 0, n, TAG_SONDEO), key=lambda t: t.offset)
              it = 0
              i = 0
              while i < n:
                  pos = base + i
                  while it < len(tags) and tags[it].offset <= pos:
                      self._info = pmt.to_python(tags[it].value)
                      it += 1
                  if self._cap is None:
                      resto = pos % self._n
                      if resto:
                          i += self._n - resto
                          continue
                      pareja = pos // self._n
                      if pareja % self._cada:
                          i += self._n
                          continue
                      self._cap = [pareja, dict(self._info)] + \
                          [np.empty(self._n, np.complex64) for _ in range(3)] + [0]
                  cap = self._cap
                  k = min(self._n - cap[5], n - i)
                  for j in range(3):
                      cap[2 + j][cap[5]:cap[5] + k] = input_items[j][i:i + k]
                  cap[5] += k
                  i += k
                  if cap[5] == self._n:
                      with self.lock:
                          self.capturas.append(tuple(cap[:5]))
                      self._cap = None
              while it < len(tags):
                  self._info = pmt.to_python(tags[it].value)
                  it += 1
              return n
    cada_n_parejas: '6'
    comment: |-
      Monitor para la GUI:
      salidas de los correladores
    n_vec: n_vec
  states: {}
- name: monitor_rx
  id: epy_block
  parameters:
    _source_code: |
      """
      Monitor de la senal recibida (solo visualizacion).

      Cada 'cada_n_parejas' parejas copia una pareja completa de disparos
      (A y luego B = 2*n_vec muestras) de la senal recibida y de los ecos sin
      ruido, junto con la informacion del tag 'sondeo' (frecuencia).
      La interfaz grafica lee el atributo 'capturas'.
      """
      import collections
      import threading
      import numpy as np
      import pmt
      from gnuradio import gr

      TAG_SONDEO = pmt.intern('sondeo')


      class blk(gr.sync_block):
          """Monitor (para la GUI): guarda cada tanto una pareja de disparos A/B de la
          senal recibida (entrada 0) y de los ecos sin ruido (entrada 1)."""

          def __init__(self, n_vec=3333, cada_n_parejas=6):
              gr.sync_block.__init__(self, name='Monitor senal recibida',
                                     in_sig=[np.complex64, np.complex64], out_sig=None)
              self._n = 2 * int(n_vec)
              self._cada = max(1, int(cada_n_parejas))
              self._info = {}
              self._cap = None
              self.lock = threading.Lock()
              self.capturas = collections.deque(maxlen=8)   # (n_pareja, info, rx, limpia)

          def work(self, input_items, output_items):
              rx, limpia = input_items
              n = len(rx)
              base = self.nitems_read(0)
              tags = sorted(self.get_tags_in_window(0, 0, n, TAG_SONDEO), key=lambda t: t.offset)
              it = 0
              i = 0
              while i < n:
                  pos = base + i
                  while it < len(tags) and tags[it].offset <= pos:
                      self._info = pmt.to_python(tags[it].value)
                      it += 1
                  if self._cap is None:
                      resto = pos % self._n
                      if resto:                                   # esperar el inicio de la pareja
                          i += self._n - resto
                          continue
                      pareja = pos // self._n
                      if pareja % self._cada:
                          i += self._n
                          continue
                      self._cap = [pareja, dict(self._info), np.empty(self._n, np.complex64),
                                   np.empty(self._n, np.complex64), 0]
                  cap = self._cap
                  k = min(self._n - cap[4], n - i)
                  cap[2][cap[4]:cap[4] + k] = rx[i:i + k]
                  cap[3][cap[4]:cap[4] + k] = limpia[i:i + k]
                  cap[4] += k
                  i += k
                  if cap[4] == self._n:
                      with self.lock:
                          self.capturas.append(tuple(cap[:4]))
                      self._cap = None
              while it < len(tags):
                  self._info = pmt.to_python(tags[it].value)
                  it += 1
              return n
    cada_n_parejas: '6'
    comment: |-
      Monitor para la GUI:
      senal recibida y ecos sin ruido
    n_vec: n_vec
  states: {}
- name: perfil_c
  id: blocks_stream_to_vector
  parameters:
    comment: |-
      Un perfil complejo
      por disparo
    num_items: n_h
    type: complex
  states: {}
- name: perfil_i
  id: blocks_stream_to_vector
  parameters:
    num_items: n_h
    type: float
  states: {}
- name: promedio
  id: blocks_multiply_const_vxx
  parameters:
    comment: 'Promedio: / K'
    const: '[1.0 / K] * n_h'
    type: float
    vlen: n_h
  states: {}
- name: selector_golay
  id: blocks_deinterleave
  parameters:
    blocksize: n_vec
    comment: |-
      Selector Golay A/B:
      bloques de n_vec muestras.
      Disparo par -> A, impar -> B
    type: complex
  states: {}
- name: simulador
  id: epy_block
  parameters:
    K: K
    _source_code: |
      """
      Simulador del sondador (reemplaza a la Red Pitaya en la simulacion).

      Genera, disparo a disparo, la senal que llegaria al receptor:
        * Transmisor: pulso BPSK de 16 chips (spb muestras por chip) con el
          codigo Golay A en los disparos pares y el B en los impares.
        * Ionosfera: capas parabolicas E y F2. Para cada frecuencia se calcula
          la altura virtual h'(f) del eco (retardo de grupo) y su atenuacion
          (absorcion en la capa D y cerca de la frecuencia critica).
        * Canal: Doppler (la fase del eco gira de un disparo al siguiente) y
          ruido gaussiano complejo de potencia 1.

      Salida 0: senal recibida = ecos + ruido (banda base compleja).
      Salida 1: los mismos ecos SIN ruido (solo para graficar).

      Cada frecuencia dura 2*K disparos (K parejas A/B). En su primera muestra
      se agrega el tag 'sondeo' = {f_mhz, paso_mhz, paso, n_pasos, barrido, modo}.
      Los parametros de la ionosfera y del canal se pueden cambiar en ejecucion;
      se aplican al comenzar la siguiente frecuencia.
      """
      import numpy as np
      import pmt
      from gnuradio import gr

      C_LUZ = 299792458.0
      HM_E, YM_E = 110.0, 20.0        # capa E: altura del maximo y semiespesor [km]
      TAG_SONDEO = pmt.intern('sondeo')


      def retardo_reflexion(x):
          """Altura virtual extra, en unidades del semiespesor ym, al reflejarse
          en una capa parabolica. x = f / fc (< 1)."""
          x = min(max(x, 0.0), 0.999)
          return 0.5 * x * np.log((1.0 + x) / (1.0 - x))


      def retardo_cruce(a):
          """Altura virtual extra, en unidades de ym, al atravesar completa una
          capa parabolica (descontado su espesor real 2*ym). a = fc / f (< 1)."""
          a = min(max(a, 1e-6), 0.999)
          return np.log((1.0 + a) / (1.0 - a)) / a - 2.0


      class blk(gr.sync_block):
          """Simulador: transmisor Golay A/B + ionosfera (capas E y F2) + Doppler + ruido.
          Salida 0 = senal recibida (ecos + ruido). Salida 1 = ecos sin ruido (solo para graficar)."""

          def __init__(self, samp_rate=200000.0, n_vec=3333, spb=6, K=25,
                       code_A=(1, 1, 1, -1, 1, 1, -1, 1, 1, 1, 1, -1, -1, -1, 1, -1),
                       code_B=(1, 1, 1, -1, 1, 1, -1, 1, -1, -1, -1, 1, 1, 1, -1, 1),
                       foE=3.0, foF2=8.0, hmF2=300.0, snr_db=-20.0, doppler_hz=0.2,
                       modo_barrido=1, f_fija=5.0, f_ini=1.0, f_fin=20.0, paso_mhz=0.1,
                       segundo_salto=1, pulso_directo=0):
              gr.sync_block.__init__(self, name='Simulador TX Golay + ionosfera',
                                     in_sig=None, out_sig=[np.complex64, np.complex64])
              # Parametros fijos (no cambian en ejecucion)
              self._fs = float(samp_rate)
              self._n_vec = int(n_vec)
              self._K = int(K)
              self._dh_km = C_LUZ / (2.0 * self._fs) / 1000.0
              self._prt = self._n_vec / self._fs
              pulso_A = np.repeat(np.asarray(code_A, dtype=np.float32), int(spb))
              pulso_B = np.repeat(np.asarray(code_B, dtype=np.float32), int(spb))
              self._pulsos = np.stack([pulso_A, pulso_B]).astype(np.complex64)
              self._n_pulso = len(pulso_A)
              # Parametros que se pueden cambiar en ejecucion (GRC genera callbacks
              # porque los atributos se llaman igual que los parametros)
              self.foE, self.foF2, self.hmF2 = foE, foF2, hmF2
              self.snr_db, self.doppler_hz = snr_db, doppler_hz
              self.modo_barrido, self.f_fija = modo_barrido, f_fija
              self.f_ini, self.f_fin, self.paso_mhz = f_ini, f_fin, paso_mhz
              self.segundo_salto, self.pulso_directo = segundo_salto, pulso_directo
              # Estado interno
              self._rng = np.random.default_rng()
              self._rx = np.zeros(0, np.complex64)
              self._limpia = np.zeros(0, np.complex64)
              self._pos = 0
              self._disparo = 0           # disparos generados (0 = primer A)
              self._barrido = 0
              self._i_paso = 0
              self._frecuencias = None
              self._clave_barrido = None

          # ------------------------------------------------------------------
          # Modelo ionosferico
          # ------------------------------------------------------------------
          def ecos(self, f_mhz):
              """Ecos a la frecuencia f_mhz: lista de (h_virtual_km, nivel_dB, nombre).
              nivel_dB es relativo al eco de referencia (el que define la SNR)."""
              f = float(f_mhz)
              foE, foF2, hmF2 = float(self.foE), float(self.foF2), float(self.hmF2)
              ymF = 0.35 * hmF2                 # semiespesor de F2 [km]
              h0E, h0F = HM_E - YM_E, hmF2 - ymF
              absorcion = 40.0 / (f + 1.0) ** 2     # capa D, ~1/f^2 [dB]
              ecos = []
              if f < foE:
                  x = f / foE
                  h = h0E + YM_E * retardo_reflexion(x)
                  perdida = absorcion + 5.0 * np.log10(1.0 / (1.0 - min(x, 0.999) ** 2))
                  ecos.append((h, -perdida, 'E'))
              elif f < foF2:
                  x = f / foF2
                  h = h0F + YM_E * retardo_cruce(foE / f) + ymF * retardo_reflexion(x)
                  perdida = absorcion + 5.0 * np.log10(1.0 / (1.0 - min(x, 0.999) ** 2))
                  ecos.append((h, -perdida, 'F2'))
              if int(self.segundo_salto) and ecos:
                  h1, nivel1, _ = ecos[0]
                  # doble recorrido: el doble de absorcion, mas dispersion y reflexion en el suelo
                  ecos.append((2.0 * h1, 2.0 * nivel1 - 9.0, '2F' if ecos[0][2] == 'F2' else '2E'))
              if int(self.pulso_directo):
                  ecos.append((0.0, 30.0, 'TX'))
              return ecos

          # ------------------------------------------------------------------
          # Planificacion del barrido
          # ------------------------------------------------------------------
          def _siguiente_frecuencia(self):
              if int(self.modo_barrido) == 0:
                  self._clave_barrido = None
                  f = float(self.f_fija)
                  return f, {'f_mhz': f, 'paso_mhz': 0.0, 'paso': 0, 'n_pasos': 1,
                             'barrido': self._barrido, 'modo': 'fija'}
              clave = (float(self.f_ini), float(self.f_fin), float(self.paso_mhz))
              if clave != self._clave_barrido:          # cambio de barrido: empezar de nuevo
                  f_ini, f_fin, paso = clave
                  self._frecuencias = np.round(np.arange(f_ini, f_fin + paso / 2.0, paso), 4)
                  self._clave_barrido = clave
                  self._i_paso = 0
                  self._barrido += 1
              elif self._i_paso >= len(self._frecuencias):
                  self._i_paso = 0
                  self._barrido += 1
              f = float(self._frecuencias[self._i_paso])
              info = {'f_mhz': f, 'paso_mhz': float(self.paso_mhz), 'paso': self._i_paso,
                      'n_pasos': len(self._frecuencias), 'barrido': self._barrido, 'modo': 'barrido'}
              self._i_paso += 1
              return f, info

          def _generar_frecuencia(self):
              """Genera los 2K disparos de una frecuencia (ecos y ecos + ruido)."""
              f, info = self._siguiente_frecuencia()
              n, n_disp = self._n_vec, 2 * self._K
              a_ref = 10.0 ** (float(self.snr_db) / 20.0)
              t = (self._disparo + np.arange(n_disp)) * self._prt         # instante de cada disparo [s]
              pulsos = self._pulsos[np.arange(n_disp) % 2]                 # A, B, A, B, ...
              limpia = np.zeros((n_disp, n), np.complex64)
              for h, nivel_db, nombre in self.ecos(f):
                  retardo = int(round(h / self._dh_km))                     # h' = c t / 2
                  if retardo >= n:
                      continue                                              # fuera de la ventana del PRT
                  fd = {'TX': 0.0, '2F': 2.0, '2E': 2.0}.get(nombre, 1.0) * float(self.doppler_hz)
                  fase = np.exp(1j * (self._rng.uniform(0, 2 * np.pi) + 2 * np.pi * fd * t))
                  amp = a_ref * 10.0 ** (nivel_db / 20.0)
                  cols = (retardo + np.arange(self._n_pulso)) % n
                  limpia[:, cols] += (amp * fase[:, None] * pulsos).astype(np.complex64)
              ruido = self._rng.standard_normal((n_disp * n, 2)).astype(np.float32)
              ruido = (ruido[:, 0] + 1j * ruido[:, 1]) * np.float32(np.sqrt(0.5))
              self._limpia = limpia.ravel()
              self._rx = (self._limpia + ruido).astype(np.complex64)
              self._pos = 0
              self._disparo += n_disp
              return info

          def work(self, input_items, output_items):
              rx, limpia = output_items
              n = len(rx)
              hecho = 0
              while hecho < n:
                  if self._pos >= len(self._rx):
                      info = self._generar_frecuencia()
                      valor = pmt.to_pmt(info)
                      for puerto in (0, 1):
                          self.add_item_tag(puerto, self.nitems_written(puerto) + hecho, TAG_SONDEO, valor)
                  k = min(n - hecho, len(self._rx) - self._pos)
                  rx[hecho:hecho + k] = self._rx[self._pos:self._pos + k]
                  limpia[hecho:hecho + k] = self._limpia[self._pos:self._pos + k]
                  self._pos += k
                  hecho += k
              return n
    code_A: code_A
    code_B: code_B
    comment: |-
      FUENTE SIMULADA (reemplaza a la Red Pitaya):
      Golay A/B + capas E/F2 + Doppler + ruido.
      Marca cada frecuencia con el tag "sondeo".
    doppler_hz: doppler_hz
    f_fija: f_fija
    f_fin: f_fin
    f_ini: f_ini
    foE: foE
    foF2: foF2
    hmF2: hmF2
    modo_barrido: modo_barrido
    n_vec: n_vec
    paso_mhz: paso_mhz
    pulso_directo: pulso_directo
    samp_rate: samp_rate
    segundo_salto: segundo_salto
    snr_db: snr_db
    spb: spb
  states: {}
- name: suma_qcc
  id: blocks_add_xx
  parameters:
    comment: |-
      Suma QCC: A + B
      (I y Q por separado)
      cancela los lobulos
    type: complex
  states: {}
- name: tipo_integracion
  id: blocks_selector
  parameters:
    comment: |-
      Elige la integracion
      (0 = coherente)
    enabled: 'True'
    input_index: integracion
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
    vlen: n_h
  states: {}
- name: ventana_alturas
  id: blocks_keep_m_in_n
  parameters:
    comment: |-
      Ventana de alturas: descarta
      las h_off muestras iniciales
      -> h' = 0 ... 2398 km
    m: n_h
    n: n_vec
    offset: h_off
    type: complex
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: zmq_addr
    comment: |-
      Perfiles -> ionogram_gui.py
      (habilitar si se usa)
    key: ''''''
    timeout: '100'
    type: float
    vlen: n_h
  states: {state: disabled}

connections:
- [blocks_throttle, '0', selector_golay, '0']
- [correlador_A, '0', monitor_correl, '0']
- [correlador_A, '0', suma_qcc, '0']
- [correlador_B, '0', monitor_correl, '1']
- [correlador_B, '0', suma_qcc, '1']
- [envolvente_c, '0', tipo_integracion, '0']
- [envolvente_i, '0', perfil_i, '0']
- [integrador_coherente, '0', envolvente_c, '0']
- [integrador_incoherente, '0', tipo_integracion, '1']
- [perfil_c, '0', integrador_coherente, '0']
- [perfil_i, '0', integrador_incoherente, '0']
- [promedio, '0', ionograma, '0']
- [promedio, '0', zeromq_pub_sink_0, '0']
- [selector_golay, '0', correlador_A, '0']
- [selector_golay, '1', correlador_B, '0']
- [simulador, '0', blocks_throttle, '0']
- [simulador, '0', monitor_rx, '0']
- [simulador, '1', monitor_rx, '1']
- [suma_qcc, '0', monitor_correl, '2']
- [suma_qcc, '0', ventana_alturas, '0']
- [tipo_integracion, '0', promedio, '0']
- [ventana_alturas, '0', envolvente_i, '0']
- [ventana_alturas, '0', perfil_c, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
