options:
  parameters:
    author: Juanjo
    description: 'Receptor del sondador ionosferico: Golay 16 bits + QCC + integracion coherente + ionograma (Red Pitaya SDRlab 122-16). GUI en ionosonde_gui.py'
    generate_options: qt_gui
    id: ionosonde_rx
    output_language: python
    title: Sondador ionosferico - Receptor Golay/QCC (Red Pitaya)
  states: {}

blocks:
- name: K
  id: variable
  parameters:
    comment: |-
      Parejas A/B integradas.
      Fijo en ejecucion.
    value: '25'
  states: {}
- name: alineacion
  id: variable
  parameters:
    comment: |-
      retardo de alineacion
      del disparo [muestras]
    value: '0'
  states: {}
- name: c_luz
  id: variable
  parameters:
    comment: Velocidad de la luz [m/s]
    value: '299792458.0'
  states: {}
- name: code_A
  id: variable
  parameters:
    comment: Codigo Golay A
    value: '[1, 1, 1, -1, 1, 1, -1, 1, 1, 1, 1, -1, -1, -1, 1, -1]'
  states: {}
- name: code_B
  id: variable
  parameters:
    comment: Codigo Golay B
    value: '[1, 1, 1, -1, 1, 1, -1, 1, -1, -1, -1, 1, 1, 1, -1, 1]'
  states: {}
- name: dh_km
  id: variable
  parameters:
    comment: |-
      km por muestra = 0.7495
      (h' = c t / 2)
    value: c_luz / (2.0 * samp_rate) / 1000.0
  states: {}
- name: f_fija
  id: variable
  parameters:
    comment: frecuencia fija [MHz]
    value: '5.0'
  states: {}
- name: f_fin
  id: variable
  parameters:
    comment: fin barrido [MHz]
    value: '20.0'
  states: {}
- name: f_ini
  id: variable
  parameters:
    comment: inicio barrido [MHz]
    value: '1.0'
  states: {}
- name: h_off
  id: variable
  parameters:
    comment: |-
      Retardo del correlador:
      eco a h -> muestra h/dh + h_off
    value: n_chips * spb - 1
  states: {}
- name: integracion
  id: variable
  parameters:
    comment: |-
      0 = coherente
      1 = incoherente
    value: '0'
  states: {}
- name: modo_barrido
  id: variable
  parameters:
    comment: |-
      Panel de control (GUI):
      1 = barrido, 0 = fija
    value: '1'
  states: {}
- name: n_chips
  id: variable
  parameters:
    comment: Chips por codigo Golay
    value: '16'
  states: {}
- name: n_h
  id: variable
  parameters:
    comment: |-
      Alturas por perfil: 0..2398 km.
      3200 = 2^7*25 -> buffers chicos
      (con 3333 cada buffer vectorial
      ocupa 218 MB en Windows)
    value: '3200'
  states: {}
- name: n_vec
  id: variable
  parameters:
    comment: |-
      Muestras por disparo (PRT)
      = 3333
    value: int(samp_rate // prf)
  states: {}
- name: paso_mhz
  id: variable
  parameters:
    comment: paso barrido [MHz]
    value: '0.1'
  states: {}
- name: prf
  id: variable
  parameters:
    comment: |-
      PRF nominal [Hz]. OJO: el TX debe
      disparar cada n_vec muestras
      (PRF real = samp_rate/n_vec)
    value: '60'
  states: {}
- name: rp_device
  id: variable
  parameters:
    comment: |-
      Dispositivo IIO del ADC.
      Verificar con:
      iio_info -u ip:192.168.1.100
    value: '''rp-adc'''
  states: {}
- name: rp_uri
  id: variable
  parameters:
    comment: URI libiio de la Red Pitaya (iiod)
    value: '''ip:192.168.1.100'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Muestreo en banda base [S/s]
      (DDC en la FPGA)
    value: '200000'
  states: {}
- name: spb
  id: variable
  parameters:
    comment: |-
      Muestras por chip
      (30 us x 200 kS/s)
    value: '6'
  states: {}
- name: swap_ab
  id: variable
  parameters:
    comment: |-
      1 = correladores A/B
      intercambiados
    value: '0'
  states: {}
- name: taps_A
  id: variable
  parameters:
    comment: |-
      Filtro adaptado A: codigo
      invertido y sobremuestreado x6
    value: np.repeat(code_B if swap_ab else code_A, spb)[::-1].astype(complex).tolist()
  states: {}
- name: taps_B
  id: variable
  parameters:
    comment: Filtro adaptado B
    value: np.repeat(code_A if swap_ab else code_B, spb)[::-1].astype(complex).tolist()
  states: {}
- name: zmq_addr
  id: variable
  parameters:
    comment: Perfiles hacia ionogram_gui.py
    value: '''tcp://127.0.0.1:5555'''
  states: {}
- name: alineacion_disparo
  id: blocks_delay
  parameters:
    comment: |-
      Alineacion del disparo:
      retrasa N muestras para que
      cada vector empiece con el TX
    delay: alineacion
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32768'
  states: {}
- name: blocks_short_to_float_1
  id: blocks_short_to_float
  parameters:
    scale: '32768'
  states: {}
- name: correlador_A
  id: fir_filter_xxx
  parameters:
    comment: |-
      Correlador A
      (filtro adaptado)
    decim: '1'
    taps: taps_A
    type: ccc
  states: {}
- name: correlador_B
  id: fir_filter_xxx
  parameters:
    comment: |-
      Correlador B
      (filtro adaptado)
    decim: '1'
    taps: taps_B
    type: ccc
  states: {}
- name: envolvente_c
  id: blocks_complex_to_mag
  parameters:
    comment: '|Z|'
    vlen: n_h
  states: {}
- name: envolvente_i
  id: blocks_complex_to_mag
  parameters:
    comment: '|Z| de cada disparo'
  states: {}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: n_vec * 4
    channels: '[''voltage0'', ''voltage1'']'
    comment: |-
      Red Pitaya SDRlab 122-16 via iiod.
      Canal voltage0 = I, voltage1 = Q.
    decimation: '1'
    device: rp_device
    device_phy: ''''''
    params: '[]'
    uri: rp_uri
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: integrador_coherente
  id: blocks_integrate_xx
  parameters:
    comment: |-
      INTEGRACION COHERENTE:
      suma K perfiles I/Q
    decim: K
    type: complex
    vlen: n_h
  states: {}
- name: integrador_incoherente
  id: blocks_integrate_xx
  parameters:
    comment: |-
      INTEGRACION INCOHERENTE:
      suma K perfiles |Z|
    decim: K
    type: float
    vlen: n_h
  states: {}
- name: interfaz_grafica
  id: snippet
  parameters:
    code: |-
      # Interfaz grafica: panel de control + pestanas de graficos.
      # El codigo esta en ionosonde_gui.py (misma carpeta que este .grc).
      import os, sys
      sys.path.insert(0, os.path.dirname(os.path.abspath(__file__)))
      import ionosonde_gui
      self._gui = ionosonde_gui.instalar(self)
    comment: |-
      Arma la GUI (controles + pestanas)
      definida en ionosonde_gui.py
    section: main_after_init
  states: {}
- name: ionograma
  id: epy_block
  parameters:
    _source_code: |
      """
      Armado del ionograma.

      Recibe cada perfil de altura ya integrado (vector de n_h alturas,
      h = i * dh_km) y, con el tag 'sondeo' que viaja junto al perfil, sabe a que
      frecuencia corresponde. Guarda:
        * matriz_db[f, h]: ionograma en dB sobre el piso de ruido de cada perfil
          (piso = mediana del perfil).
        * traza_h[f]: altura del eco mas fuerte (si supera 'umbral_db').
        * ultimo: el ultimo perfil recibido (lineal y en dB) con su frecuencia.
        * historial: los ultimos perfiles en dB (para el grafico altura-tiempo).
      La interfaz grafica lee estos atributos.
      """
      import collections
      import threading
      import numpy as np
      import pmt
      from gnuradio import gr

      TAG_SONDEO = pmt.intern('sondeo')


      class blk(gr.sync_block):
          """Armado del ionograma h'(f): ubica cada perfil integrado en la columna de su
          frecuencia (leida del tag 'sondeo') y detecta el eco mas fuerte."""

          def __init__(self, n_h=3200, dh_km=0.7494811, f_min=1.0, f_max=20.0, df_grilla=0.05,
                       umbral_db=12.0, h_min_km=80.0):
              gr.sync_block.__init__(self, name='Armado del ionograma',
                                     in_sig=[(np.float32, int(n_h))], out_sig=None)
              self.n_h = int(n_h)
              self.dh_km = float(dh_km)
              self.f_min, self.f_max, self.df = float(f_min), float(f_max), float(df_grilla)
              self.n_f = int(round((self.f_max - self.f_min) / self.df)) + 1
              self.umbral_db = umbral_db
              self._i_hmin = int(np.ceil(float(h_min_km) / self.dh_km))
              self.lock = threading.Lock()
              self._info = {}
              self.contador = 0
              self.ultimo = None                                 # (contador, info, perfil_lin, perfil_db)
              self.historial = collections.deque(maxlen=200)     # (info, perfil_db)
              self.limpiar()

          def limpiar(self):
              with self.lock:
                  self.matriz_db = np.full((self.n_f, self.n_h), np.nan, np.float32)
                  self.traza_h = np.full(self.n_f, np.nan)
                  self.traza_db = np.full(self.n_f, np.nan)

          def columnas(self, f_mhz, paso_mhz):
              """Columnas de la grilla de frecuencia que cubre un paso del barrido."""
              ancho = max(float(paso_mhz), self.df)
              i0 = int(np.floor((f_mhz - ancho / 2.0 - self.f_min) / self.df + 0.5))
              i1 = int(np.floor((f_mhz + ancho / 2.0 - self.f_min) / self.df + 0.5))
              i0, i1 = max(i0, 0), min(max(i1, i0 + 1), self.n_f)
              return i0, i1

          def work(self, input_items, output_items):
              perfiles = input_items[0]
              n = len(perfiles)
              base = self.nitems_read(0)
              info_en = {t.offset - base: pmt.to_python(t.value)
                         for t in self.get_tags_in_window(0, 0, n, TAG_SONDEO)}
              for j in range(n):
                  if j in info_en:
                      self._info = info_en[j]
                  perfil = np.array(perfiles[j], dtype=np.float32)
                  piso = float(np.median(perfil)) or 1e-12
                  perfil_db = 20.0 * np.log10(np.maximum(perfil, 1e-12) / piso)
                  f = self._info.get('f_mhz')
                  with self.lock:
                      if f is not None and self.f_min - self.df <= f <= self.f_max + self.df:
                          i0, i1 = self.columnas(f, self._info.get('paso_mhz', 0.0))
                          self.matriz_db[i0:i1] = perfil_db
                          k = self._i_hmin + int(np.argmax(perfil_db[self._i_hmin:]))
                          detectado = perfil_db[k] >= float(self.umbral_db)
                          self.traza_h[i0:i1] = k * self.dh_km if detectado else np.nan
                          self.traza_db[i0:i1] = perfil_db[k] if detectado else np.nan
                      self.contador += 1
                      self.ultimo = (self.contador, dict(self._info), perfil, perfil_db)
                      self.historial.append((dict(self._info), perfil_db))
              return n
    comment: |-
      Armado del ionograma h'(f):
      ubica cada perfil en la columna
      de su frecuencia (tag 'sondeo')
    df_grilla: '0.05'
    dh_km: dh_km
    f_max: f_fin
    f_min: f_ini
    h_min_km: '80.0'
    n_h: n_h
    umbral_db: '14.0'
  states: {}
- name: monitor_correl
  id: epy_block
  parameters:
    _source_code: |
      """
      Monitor de la compresion de pulso (solo visualizacion).

      Entradas (una muestra por muestra de disparo, n_vec por pareja):
        0: salida del correlador A, 1: salida del correlador B, 2: suma A + B.
      Cada 'cada_n_parejas' parejas copia los n_vec valores de cada entrada.
      Usa la misma regla que el monitor de la senal recibida, asi la GUI puede
      comparar la misma pareja en los dos monitores.
      """
      import collections
      import threading
      import numpy as np
      import pmt
      from gnuradio import gr

      TAG_SONDEO = pmt.intern('sondeo')


      class blk(gr.sync_block):
          """Monitor (para la GUI): guarda cada tanto la salida de los correladores A y B
          y de la suma A + B para una misma pareja de disparos."""

          def __init__(self, n_vec=3333, cada_n_parejas=6):
              gr.sync_block.__init__(self, name='Monitor compresion de pulso',
                                     in_sig=[np.complex64, np.complex64, np.complex64], out_sig=None)
              self._n = int(n_vec)
              self._cada = max(1, int(cada_n_parejas))
              self._info = {}
              self._cap = None
              self.lock = threading.Lock()
              self.capturas = collections.deque(maxlen=8)   # (n_pareja, info, A, B, A+B)

          def work(self, input_items, output_items):
              n = len(input_items[0])
              base = self.nitems_read(2)
              tags = sorted(self.get_tags_in_window(2, 0, n, TAG_SONDEO), key=lambda t: t.offset)
              it = 0
              i = 0
              while i < n:
                  pos = base + i
                  while it < len(tags) and tags[it].offset <= pos:
                      self._info = pmt.to_python(tags[it].value)
                      it += 1
                  if self._cap is None:
                      resto = pos % self._n
                      if resto:
                          i += self._n - resto
                          continue
                      pareja = pos // self._n
                      if pareja % self._cada:
                          i += self._n
                          continue
                      self._cap = [pareja, dict(self._info)] + \
                          [np.empty(self._n, np.complex64) for _ in range(3)] + [0]
                  cap = self._cap
                  k = min(self._n - cap[5], n - i)
                  for j in range(3):
                      cap[2 + j][cap[5]:cap[5] + k] = input_items[j][i:i + k]
                  cap[5] += k
                  i += k
                  if cap[5] == self._n:
                      with self.lock:
                          self.capturas.append(tuple(cap[:5]))
                      self._cap = None
              while it < len(tags):
                  self._info = pmt.to_python(tags[it].value)
                  it += 1
              return n
    cada_n_parejas: '6'
    comment: |-
      Monitor para la GUI:
      salidas de los correladores
    n_vec: n_vec
  states: {}
- name: monitor_rx
  id: epy_block
  parameters:
    _source_code: |
      """
      Monitor de la senal recibida (solo visualizacion, receptor real).

      Cada 'cada_n_parejas' parejas copia una pareja completa de disparos
      (A y luego B = 2*n_vec muestras), junto con la informacion del tag 'sondeo'
      (frecuencia). La interfaz grafica lee el atributo 'capturas'.
      """
      import collections
      import threading
      import numpy as np
      import pmt
      from gnuradio import gr

      TAG_SONDEO = pmt.intern('sondeo')


      class blk(gr.sync_block):
          """Monitor (para la GUI): guarda cada tanto una pareja de disparos A/B
          de la senal recibida."""

          def __init__(self, n_vec=3333, cada_n_parejas=6):
              gr.sync_block.__init__(self, name='Monitor senal recibida',
                                     in_sig=[np.complex64], out_sig=None)
              self._n = 2 * int(n_vec)
              self._cada = max(1, int(cada_n_parejas))
              self._info = {}
              self._cap = None
              self.lock = threading.Lock()
              self.capturas = collections.deque(maxlen=8)   # (n_pareja, info, rx, None)

          def work(self, input_items, output_items):
              rx = input_items[0]
              n = len(rx)
              base = self.nitems_read(0)
              tags = sorted(self.get_tags_in_window(0, 0, n, TAG_SONDEO), key=lambda t: t.offset)
              it = 0
              i = 0
              while i < n:
                  pos = base + i
                  while it < len(tags) and tags[it].offset <= pos:
                      self._info = pmt.to_python(tags[it].value)
                      it += 1
                  if self._cap is None:
                      resto = pos % self._n
                      if resto:                                   # esperar el inicio de la pareja
                          i += self._n - resto
                          continue
                      pareja = pos // self._n
                      if pareja % self._cada:
                          i += self._n
                          continue
                      self._cap = [pareja, dict(self._info), np.empty(self._n, np.complex64), 0]
                  cap = self._cap
                  k = min(self._n - cap[3], n - i)
                  cap[2][cap[3]:cap[3] + k] = rx[i:i + k]
                  cap[3] += k
                  i += k
                  if cap[3] == self._n:
                      with self.lock:
                          self.capturas.append((cap[0], cap[1], cap[2], None))
                      self._cap = None
              while it < len(tags):
                  self._info = pmt.to_python(tags[it].value)
                  it += 1
              return n
    cada_n_parejas: '6'
    comment: |-
      Monitor para la GUI:
      senal recibida
    n_vec: n_vec
  states: {}
- name: perfil_c
  id: blocks_stream_to_vector
  parameters:
    comment: |-
      Un perfil complejo
      por disparo
    num_items: n_h
    type: complex
  states: {}
- name: perfil_i
  id: blocks_stream_to_vector
  parameters:
    num_items: n_h
    type: float
  states: {}
- name: programador_barrido
  id: epy_block
  parameters:
    K: K
    _source_code: |
      """
      Programador del barrido de frecuencia (receptor real).

      Deja pasar la senal sin modificarla y, cada 2*K disparos (una frecuencia de
      sondeo = K parejas A/B), agrega en la primera muestra el tag
      'sondeo' = {f_mhz, paso_mhz, paso, n_pasos, barrido, modo}, el mismo que usa la
      simulacion. Asi el armado del ionograma sabe a que frecuencia corresponde cada
      perfil integrado.

      Ademas publica por el puerto de mensajes 'freq' un diccionario {'freq': f_Hz}
      al empezar cada frecuencia, para sintonizar el hardware (TX y DDC de la Red
      Pitaya). PENDIENTE: conectarlo al bloque que controle el hardware. El plan de
      barrido supone que el transmisor cambia de frecuencia en el mismo instante
      (cada 2*K*n_vec muestras desde el arranque).
      """
      import numpy as np
      import pmt
      from gnuradio import gr

      TAG_SONDEO = pmt.intern('sondeo')
      PUERTO_FREQ = pmt.intern('freq')


      class blk(gr.sync_block):
          """Programador del barrido: marca cada frecuencia de sondeo con el tag 'sondeo'
          (cada 2*K disparos) y publica {'freq': Hz} por el puerto de mensajes 'freq'."""

          def __init__(self, n_vec=3333, K=25, modo_barrido=1, f_fija=5.0, f_ini=1.0, f_fin=20.0,
                       paso_mhz=0.1):
              gr.sync_block.__init__(self, name='Programador del barrido',
                                     in_sig=[np.complex64], out_sig=[np.complex64])
              self.message_port_register_out(PUERTO_FREQ)
              self._muestras_por_paso = 2 * int(K) * int(n_vec)
              # Parametros que se pueden cambiar en ejecucion (callbacks de GRC)
              self.modo_barrido, self.f_fija = modo_barrido, f_fija
              self.f_ini, self.f_fin, self.paso_mhz = f_ini, f_fin, paso_mhz
              self._barrido = 0
              self._i_paso = 0
              self._frecuencias = None
              self._clave_barrido = None

          def _siguiente_frecuencia(self):
              if int(self.modo_barrido) == 0:
                  self._clave_barrido = None
                  f = float(self.f_fija)
                  return f, {'f_mhz': f, 'paso_mhz': 0.0, 'paso': 0, 'n_pasos': 1,
                             'barrido': self._barrido, 'modo': 'fija'}
              clave = (float(self.f_ini), float(self.f_fin), float(self.paso_mhz))
              if clave != self._clave_barrido:          # cambio de barrido: empezar de nuevo
                  f_ini, f_fin, paso = clave
                  self._frecuencias = np.round(np.arange(f_ini, f_fin + paso / 2.0, paso), 4)
                  self._clave_barrido = clave
                  self._i_paso = 0
                  self._barrido += 1
              elif self._i_paso >= len(self._frecuencias):
                  self._i_paso = 0
                  self._barrido += 1
              f = float(self._frecuencias[self._i_paso])
              info = {'f_mhz': f, 'paso_mhz': float(self.paso_mhz), 'paso': self._i_paso,
                      'n_pasos': len(self._frecuencias), 'barrido': self._barrido, 'modo': 'barrido'}
              self._i_paso += 1
              return f, info

          def work(self, input_items, output_items):
              n = len(input_items[0])
              output_items[0][:] = input_items[0]
              inicio = self.nitems_written(0)
              L = self._muestras_por_paso
              primero = -(-inicio // L) * L                 # proximo limite de frecuencia
              for offset in range(primero, inicio + n, L):
                  f, info = self._siguiente_frecuencia()
                  self.add_item_tag(0, offset, TAG_SONDEO, pmt.to_pmt(info))
                  self.message_port_pub(PUERTO_FREQ, pmt.to_pmt({'freq': f * 1e6}))
              return n
    comment: |-
      Programador del barrido: tag 'sondeo'
      cada 2K disparos + mensaje 'freq'
      (PENDIENTE: conectar a la sintonia
      del hardware)
    f_fija: f_fija
    f_fin: f_fin
    f_ini: f_ini
    modo_barrido: modo_barrido
    n_vec: n_vec
    paso_mhz: paso_mhz
  states: {}
- name: promedio
  id: blocks_multiply_const_vxx
  parameters:
    comment: 'Promedio: / K'
    const: '[1.0 / K] * n_h'
    type: float
    vlen: n_h
  states: {}
- name: selector_golay
  id: blocks_deinterleave
  parameters:
    blocksize: n_vec
    comment: |-
      Selector Golay A/B:
      bloques de n_vec muestras.
      Disparo par -> A, impar -> B
    type: complex
  states: {}
- name: suma_qcc
  id: blocks_add_xx
  parameters:
    comment: |-
      Suma QCC: A + B
      (I y Q por separado)
      cancela los lobulos
    type: complex
  states: {}
- name: tipo_integracion
  id: blocks_selector
  parameters:
    comment: |-
      Elige la integracion
      (0 = coherente)
    enabled: 'True'
    input_index: integracion
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
    vlen: n_h
  states: {}
- name: ventana_alturas
  id: blocks_keep_m_in_n
  parameters:
    comment: |-
      Ventana de alturas: descarta
      las h_off muestras iniciales
      -> h' = 0 ... 2398 km
    m: n_h
    n: n_vec
    offset: h_off
    type: complex
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: zmq_addr
    comment: |-
      Perfiles promediados (n_h alturas)
      -> ionogram_gui.py
    key: ''''''
    timeout: '100'
    type: float
    vlen: n_h
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '''tcp://127.0.0.1:5556'''
    comment: |-
      Fuente alternativa por ZMQ.
      Habilitarla y deshabilitar la rama IIO.
    key: ''''''
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [alineacion_disparo, '0', programador_barrido, '0']
- [blocks_float_to_complex_0, '0', alineacion_disparo, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_1, '0', blocks_float_to_complex_0, '1']
- [correlador_A, '0', monitor_correl, '0']
- [correlador_A, '0', suma_qcc, '0']
- [correlador_B, '0', monitor_correl, '1']
- [correlador_B, '0', suma_qcc, '1']
- [envolvente_c, '0', tipo_integracion, '0']
- [envolvente_i, '0', perfil_i, '0']
- [iio_device_source_0, '0', blocks_short_to_float_0, '0']
- [iio_device_source_0, '1', blocks_short_to_float_1, '0']
- [integrador_coherente, '0', envolvente_c, '0']
- [integrador_incoherente, '0', tipo_integracion, '1']
- [perfil_c, '0', integrador_coherente, '0']
- [perfil_i, '0', integrador_incoherente, '0']
- [programador_barrido, '0', monitor_rx, '0']
- [programador_barrido, '0', selector_golay, '0']
- [promedio, '0', ionograma, '0']
- [promedio, '0', zeromq_pub_sink_0, '0']
- [selector_golay, '0', correlador_A, '0']
- [selector_golay, '1', correlador_B, '0']
- [suma_qcc, '0', monitor_correl, '2']
- [suma_qcc, '0', ventana_alturas, '0']
- [tipo_integracion, '0', promedio, '0']
- [ventana_alturas, '0', envolvente_i, '0']
- [ventana_alturas, '0', perfil_c, '0']
- [zeromq_sub_source_0, '0', alineacion_disparo, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
